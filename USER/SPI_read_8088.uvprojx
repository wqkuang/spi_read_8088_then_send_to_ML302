# Keil uVision project SPI_read_8088.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI_read_8088 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\WDG;..\HARDWARE\uc8088;..\HARDWARE\SPI;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\STM32F10x_FWLib\inc;..\CORE;..\SYSTEM\config
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/uc8088/: uc8088_spi.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/config/: stm32f10x_it.c system_stm32f10x.c
  group FWlib
    ../STM32F10x_FWLib/src/: stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c misc.c stm32f10x_gpio.c stm32f10x_tim.c
